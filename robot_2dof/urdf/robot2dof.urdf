Commit message: v2.0

File: robot_2dof/urdf/robot2dof.urdf (robot description, URDF)
Before this commit: robot 2dof_robot, 5 links, 4 joints
Links:
- link TCP_segment: mass None -> 0.034
- link base_link: mass None -> 25
- link drugi_segment: mass None -> 2.5
- link prvi_segment: mass None -> 2.5
